# Keil uVision project rtl87x3d_audio_demo.uvprojx, settings and files
target audio_demo_cs_16M_bank0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: audio_demo
  BeforeMake: cmd.exe /c rtl87x3d_before_build_script.bat flash_cs_16M "0" rtl87x3d
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_cs_16M rtl87x3d
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_SOC_SERIES_RTL8773D=1
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\audio_demo;..\inc\rtl87x3d;..\..\..\..\inc\rtl87x3d\platform;..\..\..\..\inc\rtl87x3d\platform\cmsis;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\os;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3d\io;..\..\..\..\inc\rtl87x3d\hal;..\..\..\..\inc\rtl87x3d\hal\io;..\..\..\..\inc\hal\platform;..\..\..\..\inc\hal\io;..\..\..\..\bin\rtl87x3d\upperstack_stamp;..\..\..\..\bin\rtl87x3d\flash_map_config;..\..\..\..\src\sample\audio_demo;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\sysm;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3d\bluetooth\gap;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\inc\platform;..\..\..\..\src\mcu\module\buck;..\..\..\..\inc\hal\power;..\mdk
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3d
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3d\rtl87x3d_audio_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../../inc/rtl87x3d/platform/: rom_uuid.h
    ../: config.h
  group lib
    ../../../../bin/rtl87x3d/: gap_utils.lib ROM.lib hal_utils.lib
    ../../../../bin/rtl87x3d/framework/: audio.lib console.lib sysm.lib remote.lib btm.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3d.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../../src/sample/audio_demo/: app_dlps.c app_audio_console_msg.c app_audio_demo_console.c app_audio_demo_main.c app_audio_io_msg.c app_audio_demo_policy.c app_audio_demo_passthrough.c app_audio_demo_line_in.c app_audio_demo_anc.c app_audio_demo_pipe.c app_audio_data.c app_audio_demo_track.c app_audio_demo_vad.c app_audio_demo_kws.c
    ../../../../src/mcu/module/console/transport/: console_uart.c
    ../../../../src/mcu/module/buck/: app_buck_tps62860.c app_buck_apw7564.c
  group io_driver
    ../../../../src/mcu/io/rtl87x3d/: rtl876x_gdma.c rtl876x_uart.c rtl876x_rcc.c rtl876x_pinmux.c rtl876x_tim.c rtl876x_i2c.c rtl876x_gpio.c
  group io_hal
    ../../../../src/mcu/io_hal/common/: hw_tim.c hal_i2c.c hal_gpio.c hal_dma_internal.c hal_pinmux.c
    ../../../../src/mcu/io_hal/rtl87x3d/: hal_gpio_int.c
